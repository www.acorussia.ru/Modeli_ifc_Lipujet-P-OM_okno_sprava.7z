Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-22T18:08:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 22 18:08:25 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{AE65B911-E660-4600-85FB-FB6B8340181E}\ifc * Database version: 5507 * Database creation date: Mon May 22 18:08:24 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 22 18:08:24 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 22 18:08:24 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Ecojet_ACO:std:17779
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Ecojet; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 1472.6 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 16; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für Eco-Jet-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Ecojet_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS8.5, ME_PE_hydro jet os extension stage 2_ACO:NS8.5:17767
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: HDPE, Black, Steel, Blue, Stainless Steel, Brushed
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Ovale-Bauform-Polyethylen-PE-HD/Hydrojet-OS-Ausbaustufe-2; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 8.5; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS8.5
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_hydro jet os extension stage 2_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS8.5
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes; vent_at_entry: yes; vent_at_exit: no
Dimensions - access_entry: 1; access_entry_X: 280 mm; access_exit: 1; Area: 17.8394 m2; B: 950 mm; D: 160 mm; D_vent: 110 mm; DN: 150 mm; DN_vent: 100 mm; FH: 250 mm; FW: 230 mm; H1: 1250 mm; H2: 1180 mm; H3: 1880 mm; H4: 1700 mm; L1: 2250 mm; L2: 2485 mm; LF: 2250 mm; vent_length: 315 mm; vent_Z: 1522 mm; Volume: 0.0169882 m3; W1: 950 mm; W2: 1020 mm
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 1300 W; RSen_E_c01_apparent_power_phase_2: 1300 W; RSen_E_c01_apparent_power_phase_3: 1300 W
Electrical Engineering - RSen_E_c01_apparent_power: 3900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 150 mm; RSen_P_c02_diameter: 150 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 13; RSen_C_code_article: 3578.74.41; RSen_C_code_gtin: 04002626300133; RSen_C_description: ACO Fettabscheid. Hydrojet OS NS8.5 Dirabsg.+HD-Rg.ov.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Power
Model Properties - cleaninghead_X: 1244 mm; cleaninghead_Y: 1000 mm; cleaninghead_Z: 1463 mm; clearance_back: 525 mm; clearance_entry: 2242.5 mm; clearance_exit: 1242.5 mm; clearance_front: 1075 mm; clearance_top: 2300 mm; DN_drain: 65 mm; drain_X: 655 mm; drain_Y: 1000 mm; drain_Z: 1463 mm
Other - B_half: 475 mm; cold_water_connector: cw in; connector_escape_message: Nicht verwenden; extension_stage_lookup_table_name: eco-jet_os_extension_stage_2; Family: ME_PE_hydro jet os extension stage 2_ACO: NS8.5; Family and Type: ME_PE_hydro jet os extension stage 2_ACO: NS8.5; help_connected_phase: 3; L1_half: 1125 mm; L2_half: 1242.5 mm; lookup_table_name: eco-jet_o_basic_type; no_option: 0; option: 1; options_lookup_table_name: eco-jet_options; R: 80 mm; rev_end: 5 deg; rev_start: 0 deg; Type: ME_PE_hydro jet os extension stage 2_ACO: NS8.5; Type Id: ME_PE_hydro jet os extension stage 2_ACO: NS8.5; vent_at_entry_check: yes; vent_connector_length: 1160 mm; vent_connector_position: 90 deg
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.475 m3; overall_capacity: 1.9 m3; sludge_trap_capacity: 0.94 m3
Structural - RSen_S_gross_mass: 2143; RSen_S_net_mass: 243

# IfcFlowTerminal: std, ZZZ_do not use_ME_PE_eco-jet_o_options_ACO:std:17768
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: HDPE, Grey, HDPE, Red
Type - Identity Data - Manufacturer: ACO; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_eco-jet_o_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no; vent_at_entry: no; vent_at_exit: yes
Dimensions - access_entry: 1; access_exit: 1; access_entry_diameter: 470 mm; access_entry_X_position: 280 mm; Area: 21.8911 m2; B: 950 mm; cover_Z_position: 1587 mm; D: 160 mm; D_vent: 110 mm; DN: 150 mm; DN_vent: 100 mm; FH: 250 mm; FW: 230 mm; H1: 1250 mm; H2: 1180 mm; H3: 1880 mm; H4: 1700 mm; L1: 2250 mm; L2: 2485 mm; LF: 2250 mm; rib_height: 1563 mm; rib_number: 7; rib_width: 70 mm; vent_length: 315 mm; vent_Z_position: 1522 mm; Volume: 3.93701 m3; W1: 950 mm; W2: 1020 mm
Identity Data - Mark: 14
Model Properties - filling_device_CL: 272.6 mm; filling_device_position: 135 deg; filling_device_X: 1765 mm; filling_device_Y: 666 mm; filling_device_Z: 1200 mm; glass_position: 90 deg; glass_X: 1852.5 mm; glass_Z: 1130.5 mm; grease_measure_end_angle: 265 deg; grease_measure_position: 270 deg; grease_measure_start_angle: 270 deg; grease_measure_X: 530 mm; grease_measure_Y: 775 mm; grease_measure_Z: 1563 mm; heatrod_position: 90 deg; heatrod_X: 1540 mm; heatrod_Z: 912 mm; waterinlet_end_angle: 50 deg; waterinlet_start_angle: 45 deg
Other - access_exit_visibility: yes; B_half: 475 mm; body_height: 1463 mm; F_arc_Z_centre_pos: 135 mm; Family: ZZZ_do not use_ME_PE_eco-jet_o_options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_eco-jet_o_options_ACO: std; filling_device_option: 0; grease_measure_option: 1; heatrod_option: 1; L2_half: 1242.5 mm; LF_half: 1125 mm; lookup_table_name: eco-jet_o_basic_type; options_lookup_table_name: eco-jet_options; R: 80 mm; sight_glas_option: 0; Type: ZZZ_do not use_ME_PE_eco-jet_o_options_ACO: std; type_index: 85; Type Id: ZZZ_do not use_ME_PE_eco-jet_o_options_ACO: std; vent_at_entry_check: no; vent_connector_length: 1160 mm; vent_connector_position: 270 deg
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Ecojet_ACO:std:17778
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1130.5 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 15; RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. Eco-Jet-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Ecojet_ACO: std
Phasing - Phase Created: New Construction
